Commit message: working model

File: Simulation/ArmObj/Cube.urdf (robot description, URDF)
Before this commit: robot Cube, 1 links, 0 joints
Links:
- removed link Base_Wood
- added link Base_Cube, mass 1.0; collision box size=0.02 0.02 0.02; visual box size=0.02 0.02 0.02
